# IAR project S309.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EMB_FLASH
  ICCARM.CCIncludePath2: Inc\; Inc\CMSIS\; STM32L1xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: S309.hex
  ILINK.IlinkOutputFile: S309.out
  ILINK.IlinkIcfFile: config\stm32l152xD.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    Src/: Api.c BEBottom.C Bronco.c ComApplication.C ComBottom.C ComCoretab.c Dataproc.c DataProtect.c DLT_645_2007.c Energy.c EnergyBottom.c Event.c FunCfg.c InitPara.c Key.c LcdBottom.c Lcdmiddle.c Lcdshow.c Main.c McuDrive.c Powmanger.c Prcfrm.c PrologFee.c RtcCpt.c Spi.c Timeproc.c Uart2.c Uart3.c Version.c
    Src/startup/: startup_stm32l1xx_md.s
  group StdPeriph_Driver
    STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Vectors
    Src/: stm32l1xx_it.c
