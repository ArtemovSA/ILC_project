# IAR project ILC.ewp, settings and files
configuration ILC_edit (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZE ST STM32F407ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Middlewares/Third_Party/LwIP/src/include; ../Middlewares/Third_Party/LwIP/system; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/LwIP/src/include/netif/ppp; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/LwIP/src/include/lwip; ../Middlewares/Third_Party/LwIP/src/include/lwip/apps; ../Middlewares/Third_Party/LwIP/src/include/lwip/priv; ../Middlewares/Third_Party/LwIP/src/include/lwip/prot; ../Middlewares/Third_Party/LwIP/src/include/netif; ../Middlewares/Third_Party/LwIP/src/include/posix; ../Middlewares/Third_Party/LwIP/src/include/posix/sys; ../Middlewares/Third_Party/LwIP/system/arch; ../Drivers/CMSIS/Include; ..\Libs\MQTT; ..\Libs\TCP; ..\Libs\DevCTRL; ..\Libs\Memory; ..\Libs\Task transfer; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\Libs\V9203; ..\Libs\CRC16; ..\Libs\CRC8; ..\Libs\PCA9555; ..\Libs\EXP; ..\Libs\JSON; ..\Libs\EMS_proocol; ..\Libs\Clock; ..\Libs\Network; ..\Libs\deviceDefs; ..\Libs\FW_update; ..\Libs\USB_ctrl; ..\Libs\VM_python\conversion\inc; ..\Libs\VM_python\board; ..\Libs\VM_python; ..\Libs\USB_port; ..\Libs\VM_python\pymite\src\vm; ..\Libs\Modem; ..\Libs\Modem_gate
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\\Inc
  OBJCOPY.OOCOutputFile: ILC.bin
  ILINK.IlinkOutputFile: ILC.out
  ILINK.IlinkIcfFile: stm32f407xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: bsp_driver_sd.c ethernetif.c fatfs.c freertos.c lwip.c main.c sd_diskio.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c user_diskio.c
    ../Inc/: FreeRTOSConfig.h lwipopts.h
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_nand.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group EMS_protocol
    ../Libs/EMS_proocol/: EMS_protocol.c EMS_protocol.h
  group Libs
    ../Libs/deviceDefs/: deviceDefs.h
  group Libs/Clock
    ../Libs/Clock/: Clock.c Clock.h
  group Libs/CRC16
    ../Libs/CRC16/: CRC16.c CRC16.h
  group Libs/CRC8
    ../Libs/CRC8/: CRC8.c CRC8.h
  group Libs/DevCTRL
    ../Libs/DevCTRL/: DevCTRL.c DevCTRL.h
  group Libs/EXP
    ../Libs/EXP/: EXP.h
  group Libs/FW_update
    ../Libs/FW_update/: FW_update.c FW_update.h
  group Libs/JSON
    ../Libs/JSON/: cJSON.c cJSON.h cJSON_Utils.c cJSON_Utils.h
  group Libs/Memory
    ../Libs/Memory/: Memory.c Memory.h
  group Libs/Modem
    ../Libs/Modem/: Modem.c Modem.h
  group Libs/MQTT
    ../Libs/MQTT/: devMQTT.c devMQTT.h
  group Libs/Network
    ../Libs/Network/: Network.c Network.h
  group Libs/PCA9555
    ../Libs/PCA9555/: PCA9555.c PCA9555.h
  group Libs/Task transfer
    ../Libs/Task transfer/: Task_transfer.c Task_transfer.h
  group Libs/TCP
    ../Libs/TCP/: devTCP.c devTCP.h
  group Libs/USB_ctrl
    ../Libs/USB_ctrl/: USB_ctrl.c USB_ctrl.h
  group Libs/USB_port
    ../Libs/USB_port/: USB_port.c USB_port.h
  group Libs/V9203
    ../Libs/V9203/: V9203.c V9203.h
  group Libs/VM_python
    ../Libs/VM_python/: TASK_script.c TASK_script.h
  group Libs/VM_python/Pymite/board
    ../Libs/VM_python/board/: py_plat.c py_plat.h py_pmfeatures.h
  group Libs/VM_python/Pymite/Libs
    ../Libs/VM_python/conversion/inc/: py_std.h py_std_native.c py_usr_native.c
  group Libs/VM_python/Pymite/VM
    ../Libs/VM_python/pymite/src/vm/: py_bytearray.c py_bytearray.h py_class.c py_class.h py_codeobj.c py_codeobj.h py_dict.c py_dict.h py_float.c py_float.h py_frame.c py_frame.h py_func.c py_func.h py_global.c py_global.h py_heap.c py_heap.h py_img.c py_img.h py_int.c py_int.h py_interp.c py_interp.h py_list.c py_list.h py_mem.c py_mem.h py_module.c py_module.h py_obj.c py_obj.h py_plat_interface.h py_pm.c py_pm.h py_pmEmptyPlatformDefs.h py_pmFeatureDependencies.h py_seglist.c py_seglist.h py_seq.c py_seq.h py_sli.c py_sli.h py_strobj.c py_strobj.h py_thread.c py_thread.h py_tuple.c py_tuple.h
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c lowpan6.c slipif.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
    ../Middlewares/Third_Party/LwIP/src/apps/sntp/: sntp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Modem_gate
    ../Libs/Modem_gate/: Modem_gate.c Modem_gate.h
